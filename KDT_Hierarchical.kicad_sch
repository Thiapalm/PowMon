File: KDT_Hierarchical.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Outputs generated, ready for prototyping
Other:
- note added: "${RESULT}"
